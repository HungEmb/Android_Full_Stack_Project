## kernel/sony/msm-4.9/kernel/drivers/hvuleds/Kconfig
```kconfig
config HVU_LEDS_DRIVER
tristate "HVU LEDs Driver"
depends on ARM64
default m
help
HungVu LEDs driver
```
